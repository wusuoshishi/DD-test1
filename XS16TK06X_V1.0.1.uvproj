# Keil uVision project XS16TK06X_V1.0.1.uvproj, settings and files
target XS16TK06X (MCS-51)
  device: BF7612DM28-SJLX BF7612DMXX-XXXX
  cpu: IRAM(0-0xFF) XRAM(0-0x01FF) IROM(0-0x3FFF) CLOCK(12000000)
  output: XS16TK06X_V1.0.1_XSV1.0.0 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Inc;.\User;.\Application_Library;.\Project
  link misc: REMOVEUNUSED
  group STARTUP
    ./: STARTUP.A51
  group User
    ./User/: Other.c
  group Source
    ./Source/: Config.c XS16TK06X_LVDT.c XS16TK06X_Timer.c XS16TK06X_TK.c XS16TK06X_TraceMode.c XS16TK06X_ADC.c XS16TK06X_EEP.c XS16TK06X_Idle.c XS16TK06X_IIC.c XS16TK06X_INT.c XS16TK06X_PWM.c XS16TK06X_Read_UID.c XS16TK06X_Sleep.c XS16TK06X_UART.c
  group Library
    ./Lib/: XS16TK06X_CS_DataDeal_V1_0.LIB
  group ReadMe
    ./Doc/: ReadMe_UpdateLog.txt
  group Application_Library
    ./Application_Library/: AD.c Buz.c codingSwitch.c codingSwitch_user.c Display.c Key.c TM1628.c WORK_DEAL.c
  group Project
    ./Project/: main.c Project.c Touch_MCU_Init.c
